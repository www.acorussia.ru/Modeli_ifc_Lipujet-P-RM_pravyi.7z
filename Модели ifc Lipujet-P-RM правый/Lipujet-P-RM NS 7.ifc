Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-22T18:12:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 22 18:12:30 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{A389D839-EAF6-480A-9A4C-C78F3F6E078D}\ifc * Database version: 5507 * Database creation date: Mon May 22 18:12:28 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 22 18:12:29 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 22 18:12:29 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Ecojet_ACO:std:17184
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Ecojet; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 1863 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 12; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für Eco-Jet-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS7, ME_PE_hydro jet rs extension stage 2_ACO:NS7:17176
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: Steel, Blue, Stainless Steel, Brushed, HDPE, Black
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Runde-Bauform-Polyethylen-PE-HD/Hydrojet-RS-Ausbaustufe-2; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 7; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS7
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_hydro jet rs extension stage 2_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS7
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 22.1016 m2; D: 160 mm; D1: 1660 mm; D2: 1560 mm; D3: 1525 mm; D4: 1560 mm; disposalpump_angle: 30 deg; disposalpump_OD: 110 mm; disposalpump_X: 981.5 mm; disposalpump_Z: 135 mm; DN: 150 mm; H: 1720 mm; H1: 1430 mm; H2: 1330 mm; H3: 1880 mm; H4: 2080 mm; inlet_length: 930 mm; L1: 1820 mm; L2: 60 mm; L3: 200 mm; outlet_length: 980 mm; Volume: 0.0158786 m3
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 1300 W; RSen_E_c01_apparent_power_phase_2: 1300 W; RSen_E_c01_apparent_power_phase_3: 1300 W
Electrical Engineering - RSen_E_c01_apparent_power: 3900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 9; RSen_C_code_article: 3507.73.41; RSen_C_code_gtin: 04002626130686; RSen_C_description: ACO Fettabscheid. Hydrojet RS NS7 Dirabsg.+HD-Rg.rd.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Power
Model Properties - cleanrance_entry: 1910 mm; clearance_back: 880 mm; clearance_exit: 1010 mm; clearance_front: 1430 mm; clearance_top: 2680 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 324.4 mm; drain_Y: 437.2 mm; drain_Z: 1777 mm; motor_position: 130 deg; motor_Y: 839.2 mm; motor_Z: 524 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: eco-jet_rs_extension_stage_2; Family: ME_PE_hydro jet rs extension stage 2_ACO: NS7; Family and Type: ME_PE_hydro jet rs extension stage 2_ACO: NS7; help_connected_phase: 3; L2_half: 30 mm; lookup_table_name: ecojet_r_basic; no_option: 0; option: 1; options_lookup_table_name: ecojet_r_options; R: 80 mm; R4: 780 mm; Type: ME_PE_hydro jet rs extension stage 2_ACO: NS7; Type Id: ME_PE_hydro jet rs extension stage 2_ACO: NS7; vent_DN: 100 mm; vent_OD: 110 mm
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.4 m3; overall_capacity: 2.12 m3; sludge_trap_capacity: 0.83 m3
Structural - RSen_S_gross_mass: 2464; RSen_S_net_mass: 344

# IfcFlowTerminal: std, ZZZ_do not use_ME_PE_ecojet_r_options_ACO:std:17177
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, HDPE, Black
Type - Identity Data - Manufacturer: ACO; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_ecojet_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no
Dimensions - disposalpump_angle: 30 deg; acces_exit_X: 525 mm; access_entry_bottom_radius: 230 mm; access_entry_radius: 192.5 mm; access_entry_X_position: 525 mm; Area: 18.6286 m2; cover_Z: 1800 mm; D: 160 mm; D1: 1660 mm; D2: 1560 mm; D3: 1525 mm; D4: 1560 mm; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 22 mm; disposalpump_OD: 110 mm; disposalpump_X: 981.5 mm; disposalpump_Z: 135 mm; DN: 150 mm; H: 1720 mm; H1: 1430 mm; H2: 1330 mm; H3: 1880 mm; H4: 2080 mm; inlet_length: 930 mm; L1: 1820 mm; L2: 60 mm; L3: 200 mm; logo_Z: 777 mm; outlet_length: 980 mm; rib_number: 2; rib_thickness: 25 mm; rib_total_thickness: 57.5 mm; rib1_Z: 628.75 mm; rib2_Z: 1056.25 mm; vent_X: 160 mm; vent_Y: 500 mm; Volume: 3.57264 m3; waterinlet_angle: -20 deg; waterinlet_OD: 90 mm; waterinlet_X: 904.5 mm; waterinlet_Z: 1632 mm
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm
Identity Data - Mark: 10
Model Properties - glass_position: 90 deg; glass_X: 780 mm; glass_Z: 1302 mm; grease_measure_end_angle: 85 deg; grease_measure_start_angle: 90 deg; grease_measure_X: 0.1 mm; grease_measure_Y: 650 mm; grease_measure_Z: 1720 mm; heatrod_position: 90 deg; heatrod_Z: 932.5 mm
Other - bottom_part_Z: 603.75 mm; bottom_plate: yes; Family: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; filling_device_option: 0; grease_measure_option: 1; heatrod_option: 1; L2_half: 30 mm; logo_diameter: 1525 mm; logo_position: 90 deg; logo_radius: 762.5 mm; lookup_table_name: ecojet_r_basic; middle_part_Z: 1081.25 mm; options_lookup_table_name: ecojet_r_options; R: 80 mm; R4: 780 mm; sight_glass_option: 0; Type: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; type_index: 7; Type Id: ZZZ_do not use_ME_PE_ecojet_r_options_ACO: std; vent_DN: 100 mm; vent_length: 50 mm; vent_OD: 110 mm; waterinlet_end_angle: 15 deg; waterinlet_height: 231 mm; waterinlet_start_angle: 200 deg
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Ecojet_ACO:std:17183
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1302 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 11; RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. Eco-Jet-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std
Phasing - Phase Created: New Construction
